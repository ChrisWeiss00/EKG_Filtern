# Keil uVision project main.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L100RCTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: HSE_STARTUP_TIMEOUT=0x5000
  c include: .\src;.\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Lib
    ./Lib/: adc.h adc.c dac.h dac.c lcd.h port.h port.c pwm.h pwm.c timer.h timer.c uart.h uart.c
    ./lib/: lcd.c system_stm32l1xx.c startup_stm32l1xx_mdp.s
  group Src
    ./src/: main.c
